# Hoki LocationAPI integration for GPS clients.
IMAGE_INSTALL:append:hoki = " geoclue geoclue-provider-hybris-binder qtpositioning-geoclue"
