FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:hoki = " file://0001-pcm-detect-legacy-sync-ptr.patch"
