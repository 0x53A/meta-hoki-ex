FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-q6-pcm-account-actual-write-lengths.patch"
SRC_URI += "file://0002-q6-pcm-retain-capture-buffers.patch"
